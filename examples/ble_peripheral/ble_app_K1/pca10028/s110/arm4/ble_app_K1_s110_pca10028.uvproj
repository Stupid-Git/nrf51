# Keil uVision project ble_app_K1_s110_pca10028.uvproj, settings and files
target nrf51422_xxac_s110 (ARM-ADS)
  device: nRF51422_xxAC Nordic Semiconductor
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(16000000) ELITTLE
  output: nrf51422_xxac_s110 +hex
  c flags: Optim=4 OneElfS=1
  c define: BLE_STACK_SUPPORT_REQD S110 BOARD_PCA10028 SOFTDEVICE_PRESENT NRF51
  c misc: --c99
  c include: ..\..\..\config;..\..\..\..\..\..\..\..\nRF51_SDK\components\softdevice\s110\headers;..\..\..\..\..\..\..\..\nRF51_SDK\examples\bsp;..\..\..\..\..\..\..\..\nRF51_SDK\components\drivers_nrf\uart;..\..\..\..\..\..\..\..\nRF51_SDK\components\ble\common;..\..\..\..\..\..\..\..\nRF51_SDK\components\device;..\..\..\..\..\..\..\..\nRF51_SDK\components\toolchain;..\..\..\..\..\..\..\..\nRF51_SDK\components\libraries\fifo;..\..\..\..\..\..\..\..\nRF51_SDK\components\libraries\util;..\..\..\..\..\..\..\..\nRF51_SDK\components\libraries\button;..\..\..\..\..\..\..\..\nRF51_SDK\components\softdevice\common\softdevice_handler;..\..\..\..\..\..\..\..\nRF51_SDK\components\libraries\timer;..\..\..\..\..\..\..\..\nRF51_SDK\components\drivers_nrf\hal;..\..\..\..\..\..\..\..\nRF51_SDK\components\libraries\gpiote;..\..\..\..\..\..\..\..\nRF51_SDK\components\ble\ble_services\ble_nus
  asm define: as above
  library: MicroLIB
  memory RVCT4: ROM 0x18000 size 0x28000
  memory RVCT9: RAM 0x20002000 size 0x6000
  group Application
    ../../../: main.c main_app_uart.c
  group Board Support
    ../../../../../../../../nRF51_SDK/examples/bsp/: bsp.c
  group Device
    ../../../../../../../../nRF51_SDK/components/toolchain/arm/: arm_startup_nrf51.s
    ../../../../../../../../nRF51_SDK/components/toolchain/: system_nrf51.c
  group Documentation
    ../../../: Abstract.txt license.txt
  group nRF_BLE
    ../../../../../../../../nRF51_SDK/components/ble/common/: ble_advdata.c ble_conn_params.c ble_srv_common.c
    ../../../../../../../../nRF51_SDK/components/ble/ble_services/ble_nus/: ble_nus.c
  group nRF_Drivers
    ../../../../../../../../nRF51_SDK/components/drivers_nrf/uart/: app_uart_fifo.c
    ../../../../../../../../nRF51_SDK/components/drivers_nrf/hal/: nrf_delay.c
  group nRF_Libraries
    ../../../../../../../../nRF51_SDK/components/libraries/button/: app_button.c
    ../../../../../../../../nRF51_SDK/components/libraries/util/: app_error.c
    ../../../../../../../../nRF51_SDK/components/libraries/fifo/: app_fifo.c
    ../../../../../../../../nRF51_SDK/components/libraries/gpiote/: app_gpiote.c
    ../../../../../../../../nRF51_SDK/components/libraries/timer/: app_timer.c
    ../../../../../../../../nRF51_SDK/components/libraries/uart/: retarget.c
  group nRF_SoftDevice
    ../../../../../../../../nRF51_SDK/components/softdevice/s110/doc/: s110_nrf51_8.0.0_licence-agreement.txt
    ../../../../../../../../nRF51_SDK/components/softdevice/common/softdevice_handler/: softdevice_handler.c
target flash_softdevice (ARM-ADS)
  device: nRF51422_xxAC Nordic Semiconductor
  cpu: as above
  output: s110_softdevice.hex +hex
  c flags: Optim=4 OneElfS=1
  c define: BLE_STACK_SUPPORT_REQD
  c misc: --c99
  c include: ..\..\..\config
  asm define: BLE_STACK_SUPPORT_REQD
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
